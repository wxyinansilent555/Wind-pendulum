# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\LCD;..\USMART;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\C\core;..\head;..\head\core;..\HARDWARE\OLED;..\HARDWARE\PWM;..\SYSTEM\sys;..\HARDWARE\Control;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start_up
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c
    ../SYSTEM/usart/: usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/OLED/: OLED.c OLED.h OLED_Font.h
    ../HARDWARE/PWM/: PWM.c PWM.h
    ../HARDWARE/KEY/: Key.c Key.h
    ../HARDWARE/Control/: Control.c Control.h
    ../HARDWARE/TIMER/: Timer.c Timer.h
  group C
    ../C/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group core
    ../C/core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
